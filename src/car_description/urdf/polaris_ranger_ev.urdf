Commit message: Modif modele polaris...

File: src/car_description/urdf/polaris_ranger_ev.urdf (robot description, URDF)
Before this commit: robot polaris_ranger_ev, 12 links, 12 joints
Joints:
- removed joint rear_differential_joint
